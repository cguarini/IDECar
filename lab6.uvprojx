# Keil uVision project lab6.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK64FX512xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) IROM2(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lab6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x10000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main_template_lab6.c MK64F12.h pwm.c pwm.h uart.c uart.h camera.c camera.h steering.c steering.h Constants.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
